# IAR project DTM_Updater.ewp, settings and files
configuration UART (ARM)
  General.OGChipSelectEditMenu: BlueNRG-345 ST BlueNRG-345
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CONFIG_DEVICE_BLUENRG_LP; STEVAL_IDB011V1; CONFIG_HW_SMPS_10uH; CONFIG_HW_LS_RO; UART_INTERFACE; NO_DMA; UART_BAUDRATE=921600; CONFIG_DEVICE_BLUENRG_345
  ICCARM.CCDiagSuppress: Pe1665
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\Drivers\Peripherals_Drivers\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver; ..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver; ..\..\..\..\..\Drivers\BSP\Inc; ..\..\..\..\..\Middlewares\ST\hal\Inc; ..\..\..\..\..\Middlewares\ST\BLE_Application\layers_inc; ..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Inc; ..\..\..\..\..\Middlewares\ST\NVMDB\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DTM_Updater_UART.bin
  postbuild: "..\..\src\convert_bin2c.exe" -i "UART\Exe\DTM_Updater_UART.bin" -o "DTM_Updater_UART.c"
  ILINK.IlinkOutputFile: DTM_Updater_UART.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_SIZE=8192; CONFIG_DEVICE_BLUENRG_345=1
  ILINK.IlinkIcfFile: BlueNRG_LP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SPI (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CONFIG_DEVICE_BLUENRG_LP; STEVAL_IDB011V1; CONFIG_HW_SMPS_10uH; CONFIG_HW_LS_RO; SPI_INTERFACE; CONFIG_DEVICE_BLUENRG_345
  OBJCOPY.OOCOutputFile: DTM_Updater_SPI.bin
  postbuild: "..\..\src\convert_bin2c.exe" -i "SPI\Exe\DTM_Updater_SPI.bin" -o "DTM_Updater_SPI.c"
  ILINK.IlinkOutputFile: DTM_Updater_SPI.out
  group User
    ../../src/: DTM_Updater.c DTM_Updater_boot.c DTM_Updater_main.c
