# IAR project BLE_SensorDemo_StaticStack.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: BlueNRG-355 ST BlueNRG-355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STEVAL_IDB011V1; CONFIG_DEVICE_BLUENRG_LP; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; USER_BUTTON=BSP_PUSH1; CONFIG_HW_LS_XTAL; BLE_STACK_BASIC_CONF; CONFIG_NUM_MAX_LINKS=1
  ICCARM.CCDiagSuppress: Pe1665
  ICCARM.CCIncludePath2: ..\..\..\BLE_SensorDemo\Inc; ..\..\..\..\..\Drivers\Peripherals_Drivers\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include; ..\..\..\..\..\Middlewares\ST\hal\Inc; ..\..\..\..\..\Middlewares\ST\PKAMGR\Inc; ..\..\..\..\..\Middlewares\ST\RNGMGR\Inc; ..\..\..\..\..\Middlewares\ST\AESMGR\Inc; ..\..\..\..\..\Middlewares\ST\BLECNTR\Inc; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers/BSP/STEVAL-IDB011V1/Inc; ..\..\..\..\..\Drivers\BSP\Common\Inc; ..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver; ..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver; ..\..\..\..\..\Middlewares\ST\BLE_Application\layers_inc; ..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Inc; ..\..\..\..\..\Middlewares\ST\BLE_Application\OTA\inc; ..\..\..\..\..\Middlewares\ST\NVMDB\Inc; ..\..\..\..\..\Middlewares\ST\BLE_Application\Profiles\Inc; ..\..\..\..\..\Middlewares\ST\cryptolib\inc; ..\..\..\..\..\Middlewares\ST\cryptolib\inc\Common; ..\..\..\..\..\Middlewares\ST\cryptolib\inc\AES
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_SensorDemo_StaticStack.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_SensorDemo_StaticStack.bin"
  ILINK.IlinkOutputFile: BLE_SensorDemo_StaticStack.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_OFFSET=0x18000; MEMORY_RAM_APP_OFFSET=0x06A0
  ILINK.IlinkIcfFile: BlueNRG_LP.icf
  ILINK.IlinkExtraOptions: --use_optimized_variants no
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration LowerApp_OTA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STEVAL_IDB011V1; CONFIG_DEVICE_BLUENRG_LP; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; USER_BUTTON=BSP_PUSH1; CONFIG_HW_LS_XTAL; BLE_STACK_BASIC_CONF; CONFIG_SW_OTA_DATA_LENGTH_EXT; CONFIG_OTA_LOWER; RESET_MANAGER_SIZE=0x18000; CONFIG_NUM_MAX_LINKS=1
  OBJCOPY.OOCOutputFile: BLE_SensorDemo_StaticStack_LowerApp_OTA.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_SensorDemo_StaticStack_LowerApp_OTA.bin"
  ILINK.IlinkOutputFile: BLE_SensorDemo_StaticStack_LowerApp_OTA.out
  ILINK.IlinkConfigDefines: CONFIG_OTA_LOWER=1; RESET_MANAGER_SIZE=0x18000; MEMORY_RAM_APP_OFFSET=0x06A0
configuration HigherApp_OTA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STEVAL_IDB011V1; CONFIG_DEVICE_BLUENRG_LP; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; USER_BUTTON=BSP_PUSH1; CONFIG_HW_LS_XTAL; BLE_STACK_BASIC_CONF; CONFIG_SW_OTA_DATA_LENGTH_EXT; CONFIG_OTA_HIGHER; RESET_MANAGER_SIZE=0x18000; CONFIG_NUM_MAX_LINKS=1
  OBJCOPY.OOCOutputFile: BLE_SensorDemo_StaticStack_HigherApp_OTA.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_SensorDemo_StaticStack_HigherApp_OTA.bin"
  ILINK.IlinkOutputFile: BLE_SensorDemo_StaticStack_HigherApp_OTA.out
  ILINK.IlinkConfigDefines: CONFIG_OTA_HIGHER=1; RESET_MANAGER_SIZE=0x18000; MEMORY_RAM_APP_OFFSET=0x06A0
  group Drivers/BSP
    ../../../../../Drivers/BSP/STEVAL-IDB011V1/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_com.c bluenrg_lp_evb_i2c.c bluenrg_lp_evb_io.c bluenrg_lp_evb_led.c bluenrg_lp_evb_spi.c
    ../../../../../Drivers/BSP/Components/lps22hh_STdC/driver/: lps22hh_reg.c
    ../../../../../Drivers/BSP/Components/lsm6dsox_STdC/driver/: lsm6dsox_reg.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../../../Drivers/Peripherals_Drivers/src/: rf_driver_hal_power_manager.c rf_driver_ll_adc.c rf_driver_ll_crc.c rf_driver_ll_dma.c rf_driver_ll_exti.c rf_driver_ll_flash.c rf_driver_ll_gpio.c rf_driver_ll_i2c.c rf_driver_ll_lpuart.c rf_driver_ll_pka_v7b.c rf_driver_ll_pwr.c rf_driver_ll_rcc.c rf_driver_ll_rng.c rf_driver_ll_rtc.c rf_driver_ll_spi.c rf_driver_ll_tim.c rf_driver_ll_timer.c rf_driver_ll_usart.c rf_driver_ll_utils.c
  group Example/User
    ../../../BLE_SensorDemo/Src/: bluenrg_lp_it.c gatt_db.c sensor.c SensorDemo_main.c
  group Middlewares/BLE_Stack
    ../../../../../Middlewares/ST/Bluetooth_LE/Library/static_stack/: bluenrg_lp_stack_init_if.c libbluenrg_lp_static_stack_basic.a libbluenrg_lp_static_stack_rstmngr_basic.a
  group Middlewares/Hal
    ../../../../../Middlewares/ST/hal/Src/: blue_unit_conversion.s clock.c context_switch.s gp_timer.c hal_miscutil.c miscutil.c osal.c osal_memcpy.s
  group Middlewares/OTA
    ../../../../../Middlewares/ST/BLE_Application/OTA/Src/: OTA_btl.c
