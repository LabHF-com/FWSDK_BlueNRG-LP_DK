# IAR project BLE_OTA_ResetManager.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: BlueNRG-355 ST BlueNRG-355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STEVAL_IDB011V1; CONFIG_DEVICE_BLUENRG_LP; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; USER_BUTTON=BSP_PUSH1; CONFIG_HW_LS_XTAL
  ICCARM.CCDiagSuppress: Pe1665
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\Drivers\Peripherals_Drivers\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include; ..\..\..\..\..\Middlewares\ST\hal\Inc; ..\..\..\..\..\Middlewares\ST\PKAMGR\Inc; ..\..\..\..\..\Middlewares\ST\RNGMGR\Inc; ..\..\..\..\..\Middlewares\ST\AESMGR\Inc; ..\..\..\..\..\Middlewares\ST\BLECNTR\Inc; ..\..\..\..\..\\Middlewares\ST\BLE_Application\OTA\Inc; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers/BSP/STEVAL-IDB011V1/Inc; ..\..\..\..\..\Drivers\BSP\Common\Inc; ..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver; ..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver; ..\..\..\..\..\Middlewares\ST\BLE_Application\layers_inc; ..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Inc; ..\..\..\..\..\Middlewares\ST\NVMDB\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_OTA_ResetManager.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_OTA_ResetManager.bin"
  ILINK.IlinkOutputFile: BLE_OTA_ResetManager.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_SIZE=2048
  ILINK.IlinkIcfFile: BlueNRG_LP.icf
  ILINK.IlinkExtraOptions: --use_optimized_variants no
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/BSP
    ../../../../../Drivers/BSP/STEVAL-IDB011V1/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_com.c bluenrg_lp_evb_i2c.c bluenrg_lp_evb_led.c bluenrg_lp_evb_spi.c
    ../../../../../Drivers/BSP/Components/lps22hh_STdC/driver/: lps22hh_reg.c
    ../../../../../Drivers/BSP/Components/lsm6dsox_STdC/driver/: lsm6dsox_reg.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../../../Drivers/Peripherals_Drivers/Src/: rf_driver_hal_power_manager.c rf_driver_hal_vtimer.c rf_driver_ll_adc.c rf_driver_ll_crc.c rf_driver_ll_dma.c rf_driver_ll_exti.c rf_driver_ll_flash.c rf_driver_ll_gpio.c rf_driver_ll_i2c.c rf_driver_ll_lpuart.c rf_driver_ll_pka_v7b.c rf_driver_ll_pwr.c rf_driver_ll_radio_2g4.c rf_driver_ll_rcc.c rf_driver_ll_rng.c rf_driver_ll_rtc.c rf_driver_ll_spi.c rf_driver_ll_tim.c rf_driver_ll_timer.c rf_driver_ll_usart.c rf_driver_ll_utils.c
  group Example/User
    ../../Src/: bluenrg_lp_it.c OTA_ResetManager_main.c
  group Middlewares/BLE_Stack
    ../../../../../Middlewares/ST/Bluetooth_LE/Library/: libbluenrgLP_stack.a
    ../../../../../Middlewares/ST/Bluetooth_LE/Src/: stack_user_cfg.c
  group Middlewares/Cryptolib
    ../../../../../Middlewares/ST/cryptolib/: libcrypto.a
  group Middlewares/Hal
    ../../../../../Middlewares/ST/hal/Src/: blue_unit_conversion.s context_switch.s fifo.c hal_miscutil.c miscutil.c osal.c osal_memcpy.s
  group Middlewares/NVM
    ../../../../../Middlewares/ST/NVMDB/Src/: nvm_db.c nvm_db_conf.c nvm_db_upper_layer.c
