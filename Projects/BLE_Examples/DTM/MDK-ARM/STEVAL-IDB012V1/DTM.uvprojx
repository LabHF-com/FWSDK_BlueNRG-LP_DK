# Keil uVision project DTM.uvprojx, settings and files
target UART (6160000::V6.16::ARMCLANG)
  device: BlueNRG-332 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.1.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: DTM_UART +hex
  AfterMake: fromelf.exe --bin UART\Objects\DTM_UART.axf --output UART\Objects\DTM_UART.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CONFIG_DEVICE_BLUENRG_LPS SUPPRESS_CONFIG_HW_WARNINGS STEVAL_IDB012V1 USE_FULL_LL_DRIVER UART_INTERFACE UART_BAUDRATE=921600 WATCHDOG WATCHDOG_TIME=1 NUM_ADV_SETS_CONF=2 BLE_STACK_CUSTOM_CONF CONFIG_NUM_MAX_LINKS=3 CONFIG_NO_HCI_COMMANDS
  c misc: -fshort-enums
  c include: ..\..\Inc;..\..\..\..\..\Drivers\Peripherals_Drivers\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include;..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver;..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver;..\..\..\..\..\Drivers\BSP\Inc;..\..\..\..\..\Middlewares\ST\hal\Inc;..\..\..\..\..\Middlewares\ST\PKAMGR\Inc;..\..\..\..\..\Middlewares\ST\RNGMGR\Inc;..\..\..\..\..\Middlewares\ST\AESMGR\Inc;..\..\..\..\..\Middlewares\ST\BLECNTR\Inc;..\..\..\..\..\Middlewares\ST\BLE_Application\layers_inc;..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Inc;..\..\..\..\..\Middlewares\ST\NVMDB\Inc;..\..\..\..\..\Middlewares\ST\BLE_Application\Profiles\Inc;..\..\..\..\..\Middlewares\ST\BLE_Application\Queued_Write\Inc;..\..\..\..\..\Middlewares\ST\cryptolib\Inc;..\..\..\..\..\Middlewares\ST\cryptolib\Inc\AES;..\..\..\..\..\Middlewares\ST\cryptolib\Inc\Common
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LPS.sct
  group Application/DTM_Updater
    ../../DTM_Updater/: DTM_Updater_SPI.c DTM_Updater_UART.c
  group Application/User
    ../../Src/: aci_adv_nwk.c aci_gatt_nwk.c aci_l2cap_nwk.c adv_buff_alloc.c cmd.c dm_alloc.c DTM_boot.c DTM_burst.c DTM_cmd_db.c DTM_cmds.c DTM_main.c hci_parser.c hw_config.c rf_device_it.c transport_layer.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: startup_BlueNRG_LP.c system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../../../Drivers/Peripherals_Drivers/Src/: rf_driver_hal_power_manager.c rf_driver_hal_vtimer.c rf_driver_ll_dma.c rf_driver_ll_exti.c rf_driver_ll_flash.c rf_driver_ll_gpio.c rf_driver_ll_pka_v7c.c rf_driver_ll_rcc.c rf_driver_ll_spi.c rf_driver_ll_timer.c rf_driver_ll_usart.c
  group Middlewares/AES
    ../../../../../Middlewares/ST/AESMGR/Src/: aes_manager_bluenrg_lp.c
  group Middlewares/BLE_Stack
    ../../../../../Middlewares/ST/Bluetooth_LE/Library/: libbluenrg_lp_stack.a libbluenrg_lp_stack_controller_only.a
    ../../../../../Middlewares/ST/Bluetooth_LE/Src/: stack_user_cfg.c
  group Middlewares/BLECNTR
    ../../../../../Middlewares/ST/BLECNTR/Src/: ble_controller.c ble_controller_bluenrg_lp.c
  group Middlewares/Cryptolib
    ../../../../../Middlewares/ST/cryptolib/: aes_hw.c libcrypto.a
  group Middlewares/Hal
    ../../../../../Middlewares/ST/hal/Src/: blue_unit_conversion.s context_switch.s fifo.c hal_miscutil.c miscutil.c osal.c osal_memcpy.s
  group Middlewares/NVM
    ../../../../../Middlewares/ST/NVMDB/Src/: nvm_db.c nvm_db_conf.c nvm_db_upper_layer.c
  group Middlewares/PKA
    ../../../../../Middlewares/ST/PKAMGR/Src/: pka_manager.c pka_manager_bluenrg_lps.c
  group Middlewares/Profiles
    ../../../../../Middlewares/ST/BLE_Application/Profiles/Src/: gap_profile.c gatt_profile.c
  group Middlewares/Queued_Write
    ../../../../../Middlewares/ST/BLE_Application/Queued_Write/Src/: eatt_pwrq.c
  group Middlewares/RNG
    ../../../../../Middlewares/ST/RNGMGR/Src/: rng_manager.c rng_manager_bluenrg_lp.c
target UART_WITH_UPDATER (6160000::V6.16::ARMCLANG)
  device: BlueNRG-332 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.1.1
  cpu: as above
  output: DTM_UART_WITH_UPDATER +hex
  AfterMake: fromelf.exe --bin UART_WITH_UPDATER\Objects\DTM_UART_WITH_UPDATER.axf --output UART_WITH_UPDATER\Objects\DTM_UART_WITH_UPDATER.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: -fshort-enums
  c include: ..\..\Inc;..\..\..\..\..\Drivers\Peripherals_Drivers\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include;..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver;..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver;..\..\..\..\..\Drivers\BSP\Inc;..\..\..\..\..\Middlewares\ST\hal\Inc;..\..\..\..\..\Middlewares\ST\PKAMGR\Inc;..\..\..\..\..\Middlewares\ST\RNGMGR\Inc;..\..\..\..\..\Middlewares\ST\AESMGR\Inc;..\..\..\..\..\Middlewares\ST\BLECNTR\Inc;..\..\..\..\..\Middlewares\ST\BLE_Application\layers_inc;..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Inc;..\..\..\..\..\Middlewares\ST\NVMDB\Inc;..\..\..\..\..\Middlewares\ST\BLE_Application\Profiles\Inc;..\..\..\..\..\Middlewares\ST\BLE_Application\Queued_Write\Inc;..\..\..\..\..\Middlewares\ST\cryptolib\Inc;..\..\..\..\..\Middlewares\ST\cryptolib\Inc\Common;..\..\..\..\..\Middlewares\ST\cryptolib\Inc\AES
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LPS.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_OFFSET=4096 "
target UART_FOR_UPDATER (6160000::V6.16::ARMCLANG)
  device: BlueNRG-332 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.1.1
  cpu: as above
  output: DTM_UART_FOR_UPDATER +hex
  AfterMake: fromelf.exe --bin UART_FOR_UPDATER\Objects\DTM_UART_FOR_UPDATER.axf --output UART_FOR_UPDATER\Objects\DTM_UART_FOR_UPDATER.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CONFIG_DEVICE_BLUENRG_LPS SUPPRESS_CONFIG_HW_WARNINGS STEVAL_IDB012V1 USE_FULL_LL_DRIVER UART_INTERFACE UART_BAUDRATE=921600 WATCHDOG WATCHDOG_TIME=1 BLE_STACK_CUSTOM_CONF NUM_ADV_SETS_CONF=2 CONFIG_NUM_MAX_LINKS=3 CONFIG_NO_HCI_COMMANDS
  c misc: -fshort-enums
  c include: as above
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LPS.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_OFFSET=4096 "
target SPI (6160000::V6.16::ARMCLANG)
  device: BlueNRG-332 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.1.1
  cpu: as above
  output: DTM_SPI +hex
  AfterMake: fromelf.exe --bin SPI\Objects\DTM_SPI.axf --output SPI\Objects\DTM_SPI.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CONFIG_DEVICE_BLUENRG_LPS SUPPRESS_CONFIG_HW_WARNINGS STEVAL_IDB012V1 USE_FULL_LL_DRIVER SPI_INTERFACE WATCHDOG WATCHDOG_TIME=2 BLE_STACK_CUSTOM_CONF __DMA_16 NUM_ADV_SETS_CONF=2 CONFIG_NUM_MAX_LINKS=3 CONFIG_NO_HCI_COMMANDS
  c misc: -fshort-enums
  c include: as above
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LPS.sct
target SPI_WITH_UPDATER (6160000::V6.16::ARMCLANG)
  device: BlueNRG-332 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.1.1
  cpu: as above
  output: DTM_SPI_WITH_UPDATER +hex
  AfterMake: fromelf.exe --bin SPI_WITH_UPDATER\Objects\DTM_SPI_WITH_UPDATER.axf --output SPI_WITH_UPDATER\Objects\DTM_SPI_WITH_UPDATER.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: -fshort-enums
  c include: as above
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LPS.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_OFFSET=4096 "
target SPI_FOR_UPDATER (6160000::V6.16::ARMCLANG)
  device: BlueNRG-332 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.1.1
  cpu: as above
  output: DTM_SPI_FOR_UPDATER +hex
  AfterMake: fromelf.exe --bin SPI_FOR_UPDATER\Objects\DTM_SPI_FOR_UPDATER.axf --output SPI_FOR_UPDATER\Objects\DTM_SPI_FOR_UPDATER.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: -fshort-enums
  c include: as above
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LPS.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_OFFSET=4096 "
target UART_WITH_UPDATER_CONTROLLER (6160000::V6.16::ARMCLANG)
  device: BlueNRG-332 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.1.1
  cpu: as above
  output: DTM_UART_WITH_UPDATER_CONTROLLER +hex
  AfterMake: fromelf.exe --bin UART_WITH_UPDATER_CONTROLLER\Objects\DTM_UART_WITH_UPDATER_CONTROLLER.axf --output UART_WITH_UPDATER_CONTROLLER\Objects\DTM_UART_WITH_UPDATER_CONTROLLER.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CONFIG_DEVICE_BLUENRG_LPS SUPPRESS_CONFIG_HW_WARNINGS STEVAL_IDB012V1 USE_FULL_LL_DRIVER UART_INTERFACE UART_BAUDRATE=921600 WATCHDOG WATCHDOG_TIME=1 NUM_ADV_SETS_CONF=2 BLE_STACK_FULL_CONF CONFIG_NUM_MAX_LINKS=3 BLESTACK_CONTROLLER_ONLY=1
  c misc: -fshort-enums
  c include: as above
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LPS.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_OFFSET=4096 "
target SPI_WITH_UPDATER_CONTROLLER (6160000::V6.16::ARMCLANG)
  device: BlueNRG-332 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.1.1
  cpu: as above
  output: DTM_SPI_WITH_UPDATER_CONTROLLER +hex
  AfterMake: fromelf.exe --bin SPI_WITH_UPDATER_CONTROLLER\Objects\DTM_SPI_WITH_UPDATER_CONTROLLER.axf --output SPI_WITH_UPDATER_CONTROLLER\Objects\DTM_SPI_WITH_UPDATER_CONTROLLER.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CONFIG_DEVICE_BLUENRG_LPS SUPPRESS_CONFIG_HW_WARNINGS STEVAL_IDB012V1 USE_FULL_LL_DRIVER SPI_INTERFACE WATCHDOG WATCHDOG_TIME=1 NUM_ADV_SETS_CONF=2 BLE_STACK_FULL_CONF CONFIG_NUM_MAX_LINKS=3 BLESTACK_CONTROLLER_ONLY=1
  c misc: -fshort-enums
  c include: as above
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LPS.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_OFFSET=4096 "
