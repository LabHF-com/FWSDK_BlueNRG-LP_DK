# IAR project DTM.ewp, settings and files
configuration UART (ARM)
  General.OGChipSelectEditMenu: BlueNRG-332 ST BlueNRG-332
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CONFIG_DEVICE_BLUENRG_LPS; SUPPRESS_CONFIG_HW_WARNINGS; STEVAL_IDB012V1; USE_FULL_LL_DRIVER; UART_INTERFACE; UART_BAUDRATE=921600; WATCHDOG; WATCHDOG_TIME=1; NUM_ADV_SETS_CONF=2; BLE_STACK_CUSTOM_CONF; CONFIG_NUM_MAX_LINKS=3; CONFIG_NO_HCI_COMMANDS
  ICCARM.CCDiagSuppress: Pe1665, Pa183
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\Drivers\Peripherals_Drivers\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver; ..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver; ..\..\..\..\..\Drivers\BSP\Inc; ..\..\..\..\..\Middlewares\ST\hal\Inc; ..\..\..\..\..\Middlewares\ST\PKAMGR\Inc; ..\..\..\..\..\Middlewares\ST\RNGMGR\Inc; ..\..\..\..\..\Middlewares\ST\AESMGR\Inc; ..\..\..\..\..\Middlewares\ST\BLECNTR\Inc; ..\..\..\..\..\Middlewares\ST\BLE_Application\layers_inc; ..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Inc; ..\..\..\..\..\Middlewares\ST\NVMDB\Inc; ..\..\..\..\..\Middlewares\ST\BLE_Application\Profiles\Inc; ..\..\..\..\..\Middlewares\ST\BLE_Application\Queued_Write\Inc; ..\..\..\..\..\Middlewares\ST\cryptolib\Inc; ..\..\..\..\..\Middlewares\ST\cryptolib\Inc\AES; ..\..\..\..\..\Middlewares\ST\cryptolib\Inc\Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DTM_UART.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\DTM_UART.bin"
  ILINK.IlinkOutputFile: DTM_UART.out
  ILINK.IlinkIcfFile: BlueNRG_LPS.icf
  ILINK.IlinkExtraOptions: --use_optimized_variants no
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration UART_WITH_UPDATER (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\Drivers\Peripherals_Drivers\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver; ..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver; ..\..\..\..\..\Drivers\BSP\Inc; ..\..\..\..\..\Middlewares\ST\hal\Inc; ..\..\..\..\..\Middlewares\ST\PKAMGR\Inc; ..\..\..\..\..\Middlewares\ST\RNGMGR\Inc; ..\..\..\..\..\Middlewares\ST\AESMGR\Inc; ..\..\..\..\..\Middlewares\ST\BLECNTR\Inc; ..\..\..\..\..\Middlewares\ST\BLE_Application\layers_inc; ..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Inc; ..\..\..\..\..\Middlewares\ST\NVMDB\Inc; ..\..\..\..\..\Middlewares\ST\BLE_Application\Profiles\Inc; ..\..\..\..\..\Middlewares\ST\BLE_Application\Queued_Write\Inc; ..\..\..\..\..\Middlewares\ST\cryptolib\Inc; ..\..\..\..\..\Middlewares\ST\cryptolib\Inc\Common; ..\..\..\..\..\Middlewares\ST\cryptolib\Inc\AES
  OBJCOPY.OOCOutputFile: DTM_UART_WITH_UPDATER.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\DTM_UART_WITH_UPDATER.bin"
  ILINK.IlinkOutputFile: DTM_UART_WITH_UPDATER.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_OFFSET=4096
configuration UART_FOR_UPDATER (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CONFIG_DEVICE_BLUENRG_LPS; SUPPRESS_CONFIG_HW_WARNINGS; STEVAL_IDB012V1; USE_FULL_LL_DRIVER; UART_INTERFACE; UART_BAUDRATE=921600; WATCHDOG; WATCHDOG_TIME=1; BLE_STACK_CUSTOM_CONF; NUM_ADV_SETS_CONF=2; CONFIG_NUM_MAX_LINKS=3; CONFIG_NO_HCI_COMMANDS
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: DTM_UART_FOR_UPDATER.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\DTM_UART_FOR_UPDATER.bin"
  ILINK.IlinkOutputFile: DTM_UART_FOR_UPDATER.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_OFFSET=4096
configuration SPI (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CONFIG_DEVICE_BLUENRG_LPS; SUPPRESS_CONFIG_HW_WARNINGS; STEVAL_IDB012V1; USE_FULL_LL_DRIVER; SPI_INTERFACE; WATCHDOG; WATCHDOG_TIME=2; BLE_STACK_CUSTOM_CONF; __DMA_16; NUM_ADV_SETS_CONF=2; CONFIG_NUM_MAX_LINKS=3; CONFIG_NO_HCI_COMMANDS
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: DTM_SPI.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\DTM_SPI.bin"
  ILINK.IlinkOutputFile: DTM_SPI.out
configuration SPI_WITH_UPDATER (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: DTM_SPI_WITH_UPDATER.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\DTM_SPI_WITH_UPDATER.bin"
  ILINK.IlinkOutputFile: DTM_SPI_WITH_UPDATER.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_OFFSET=4096
configuration SPI_FOR_UPDATER (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: DTM_SPI_FOR_UPDATER.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\DTM_SPI_FOR_UPDATER.bin"
  ILINK.IlinkOutputFile: DTM_SPI_FOR_UPDATER.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_OFFSET=4096
configuration UART_WITH_UPDATER_CONTROLLER (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CONFIG_DEVICE_BLUENRG_LPS; SUPPRESS_CONFIG_HW_WARNINGS; STEVAL_IDB012V1; USE_FULL_LL_DRIVER; UART_INTERFACE; UART_BAUDRATE=921600; WATCHDOG; WATCHDOG_TIME=1; NUM_ADV_SETS_CONF=2; BLE_STACK_FULL_CONF; CONFIG_NUM_MAX_LINKS=3; BLESTACK_CONTROLLER_ONLY=1
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: DTM_UART_WITH_UPDATER_CONTROLLER.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\DTM_UART_WITH_UPDATER_CONTROLLER.bin"
  ILINK.IlinkOutputFile: DTM_UART_WITH_UPDATER_CONTROLLER.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_OFFSET=4096
configuration SPI_WITH_UPDATER_CONTROLLER (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CONFIG_DEVICE_BLUENRG_LPS; SUPPRESS_CONFIG_HW_WARNINGS; STEVAL_IDB012V1; USE_FULL_LL_DRIVER; SPI_INTERFACE; WATCHDOG; WATCHDOG_TIME=1; NUM_ADV_SETS_CONF=2; BLE_STACK_FULL_CONF; CONFIG_NUM_MAX_LINKS=3; BLESTACK_CONTROLLER_ONLY=1
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: DTM_SPI_WITH_UPDATER_CONTROLLER.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\DTM_SPI_WITH_UPDATER_CONTROLLER.bin"
  ILINK.IlinkOutputFile: DTM_SPI_WITH_UPDATER_CONTROLLER.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_OFFSET=4096
  group Application/DTM_Updater
    ../../DTM_Updater/: DTM_Updater_SPI.c DTM_Updater_UART.c
  group Application/User
    ../../Src/: aci_adv_nwk.c aci_gatt_nwk.c aci_l2cap_nwk.c adv_buff_alloc.c cmd.c dm_alloc.c DTM_boot.c DTM_burst.c DTM_cmd_db.c DTM_cmds.c DTM_main.c hci_parser.c hw_config.c rf_device_it.c transport_layer.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: startup_BlueNRG_LP.c system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../../../Drivers/Peripherals_Drivers/Src/: rf_driver_hal_power_manager.c rf_driver_hal_vtimer.c rf_driver_ll_dma.c rf_driver_ll_exti.c rf_driver_ll_flash.c rf_driver_ll_gpio.c rf_driver_ll_pka_v7c.c rf_driver_ll_rcc.c rf_driver_ll_spi.c rf_driver_ll_timer.c rf_driver_ll_usart.c
  group Middlewares/AES
    ../../../../../Middlewares/ST/AESMGR/Src/: aes_manager_bluenrg_lp.c
  group Middlewares/BLE_Stack
    ../../../../../Middlewares/ST/Bluetooth_LE/Library/: libbluenrg_lp_stack.a libbluenrg_lp_stack_controller_only.a
    ../../../../../Middlewares/ST/Bluetooth_LE/Src/: stack_user_cfg.c
  group Middlewares/BLECNTR
    ../../../../../Middlewares/ST/BLECNTR/Src/: ble_controller.c ble_controller_bluenrg_lp.c
  group Middlewares/Cryptolib
    ../../../../../Middlewares/ST/cryptolib/: aes_hw.c libcrypto.a
  group Middlewares/Hal
    ../../../../../Middlewares/ST/hal/Src/: blue_unit_conversion.s context_switch.s fifo.c hal_miscutil.c miscutil.c osal.c osal_memcpy.s
  group Middlewares/NVM
    ../../../../../Middlewares/ST/NVMDB/Src/: nvm_db.c nvm_db_conf.c nvm_db_upper_layer.c
  group Middlewares/PKA
    ../../../../../Middlewares/ST/PKAMGR/Src/: pka_manager.c pka_manager_bluenrg_lps.c
  group Middlewares/Profiles
    ../../../../../Middlewares/ST/BLE_Application/Profiles/Src/: gap_profile.c gatt_profile.c
  group Middlewares/Queued_Write
    ../../../../../Middlewares/ST/BLE_Application/Queued_Write/Src/: eatt_pwrq.c
  group Middlewares/RNG
    ../../../../../Middlewares/ST/RNGMGR/Src/: rng_manager.c rng_manager_bluenrg_lp.c
