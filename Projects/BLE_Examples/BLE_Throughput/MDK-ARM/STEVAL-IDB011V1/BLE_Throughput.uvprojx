# Keil uVision project BLE_Throughput.uvprojx, settings and files
target Client (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.1.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BLE_Throughput_Client +hex
  AfterMake: fromelf.exe --bin Client\Objects\BLE_Throughput_Client.axf --output Client\Objects\BLE_Throughput_Client.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_FULL_LL_DRIVER STEVAL_IDB011V1 CLIENT=1 BSP_UART_BAUDRATE=921600 CONFIG_DEVICE_BLUENRG_LP CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 USER_BUTTON=BSP_PUSH1 CONFIG_HW_LS_XTAL BLE_STACK_CUSTOM_CONF SET_PHY=1 NO_RECONNECT TX_POWER=25
  c include: ..\..\Inc;..\..\..\..\..\Drivers\Peripherals_Drivers\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include;..\..\..\..\..\Middlewares\ST\hal\Inc;..\..\..\..\..\Middlewares\ST\PKAMGR\Inc;..\..\..\..\..\Middlewares\ST\RNGMGR\Inc;..\..\..\..\..\Middlewares\ST\AESMGR\Inc;..\..\..\..\..\Middlewares\ST\BLECNTR\Inc;..\..\..\..\..\Drivers\CMSIS\Include;../../../../../Drivers/BSP/STEVAL-IDB011V1/Inc;..\..\..\..\..\Drivers\BSP\Common\Inc;..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver;..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver;..\..\..\..\..\Middlewares\ST\BLE_Application\layers_inc;..\..\..\..\..\Middlewares\ST\BLE_Application\OTA\inc;..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Inc;..\..\..\..\..\Middlewares\ST\NVMDB\Inc;..\..\..\..\..\Middlewares\ST\BLE_Application\Profiles\Inc;..\..\..\..\..\Middlewares\ST\cryptolib\inc;..\..\..\..\..\Middlewares\ST\cryptolib\inc\Common;..\..\..\..\..\Middlewares\ST\cryptolib\inc\AES
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
  group Drivers/BSP
    ../../../../../Drivers/BSP/STEVAL-IDB011V1/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_com.c bluenrg_lp_evb_i2c.c bluenrg_lp_evb_io.c bluenrg_lp_evb_led.c bluenrg_lp_evb_spi.c
    ../../../../../Drivers/BSP/Components/lps22hh_STdC/driver/: lps22hh_reg.c
    ../../../../../Drivers/BSP/Components/lsm6dsox_STdC/driver/: lsm6dsox_reg.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../../../Drivers/Peripherals_Drivers/src/: rf_driver_hal_power_manager.c rf_driver_hal_vtimer.c rf_driver_ll_adc.c rf_driver_ll_crc.c rf_driver_ll_dma.c rf_driver_ll_exti.c rf_driver_ll_flash.c rf_driver_ll_gpio.c rf_driver_ll_i2c.c rf_driver_ll_lpuart.c rf_driver_ll_pka_v7b.c rf_driver_ll_pwr.c rf_driver_ll_radio_2g4.c rf_driver_ll_rcc.c rf_driver_ll_rng.c rf_driver_ll_rtc.c rf_driver_ll_spi.c rf_driver_ll_tim.c rf_driver_ll_timer.c rf_driver_ll_usart.c rf_driver_ll_utils.c
  group Example/User
    ../../Src/: BLE_Throughput_main.c bluenrg_lp_it.c gatt_db.c throughput.c
    ../../../../../Middlewares/ST/hal/Src/: hal_miscutil.c
  group Middlewares/AES
    ../../../../../Middlewares/ST/AESMGR/Src/: aes_manager_bluenrg_lp.c
  group Middlewares/BLE_Stack
    ../../../../../Middlewares/ST/Bluetooth_LE/Library/: libbluenrg_lp_stack.a
    ../../../../../Middlewares/ST/Bluetooth_LE/Src/: stack_user_cfg.c
  group Middlewares/BLECNTR
    ../../../../../Middlewares/ST/BLECNTR/Src/: ble_controller.c ble_controller_bluenrg_lp.c
  group Middlewares/Cryptolib
    ../../../../../Middlewares/ST/cryptolib/: aes_hw.c libcrypto.a
  group Middlewares/Hal
    ../../../../../Middlewares/ST/hal/Src/: blue_unit_conversion.s clock.c context_switch.s fifo.c gp_timer.c miscutil.c osal.c osal_memcpy.s
  group Middlewares/NVM
    ../../../../../Middlewares/ST/NVMDB/Src/: nvm_db.c nvm_db_conf.c nvm_db_upper_layer.c
  group Middlewares/PKA
    ../../../../../Middlewares/ST/PKAMGR/Src/: pka_manager.c pka_manager_bluenrg_lp.c
  group Middlewares/Profiles
    ../../../../../Middlewares/ST/BLE_Application/Profiles/Src/: gap_profile.c gatt_profile.c
  group Middlewares/RNG
    ../../../../../Middlewares/ST/RNGMGR/Src/: rng_manager.c rng_manager_bluenrg_lp.c
target Server (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.1.0.0
  cpu: as above
  output: BLE_Throughput_Server +hex
  AfterMake: fromelf.exe --bin Server\Objects\BLE_Throughput_Server.axf --output Server\Objects\BLE_Throughput_Server.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_FULL_LL_DRIVER STEVAL_IDB011V1 CONFIG_DEVICE_BLUENRG_LP CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 USER_BUTTON=BSP_PUSH1 SERVER=1 BSP_UART_BAUDRATE=921600 CONFIG_HW_LS_XTAL BLE_STACK_CUSTOM_CONF SET_PHY=1 NO_RECONNECT TX_POWER=25
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
