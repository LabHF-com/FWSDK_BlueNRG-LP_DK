# IAR project BLE_Beacon.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: BlueNRG-332 ST BlueNRG-332
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STEVAL_IDB012V1; CONFIG_DEVICE_BLUENRG_LPS; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; USER_BUTTON=BSP_PUSH1; CONFIG_HW_LS_XTAL; BLE_STACK_CUSTOM_CONF; LEGACY_ADV; CONFIG_NUM_MAX_LINKS=1
  ICCARM.CCDiagSuppress: Pe1665
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\Drivers\Peripherals_Drivers\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include; ..\..\..\..\..\Middlewares\ST\hal\Inc; ..\..\..\..\..\Middlewares\ST\PKAMGR\Inc; ..\..\..\..\..\Middlewares\ST\RNGMGR\Inc; ..\..\..\..\..\Middlewares\ST\AESMGR\Inc; ..\..\..\..\..\Middlewares\ST\BLECNTR\Inc; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\BSP\Inc; ..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver; ..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver; ..\..\..\..\..\Middlewares\ST\BLE_Application\layers_inc; ..\..\..\..\..\Middlewares\ST\BLE_Application\OTA\Inc; ..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Inc; ..\..\..\..\..\Middlewares\ST\NVMDB\Inc; ..\..\..\..\..\Middlewares\ST\BLE_Application\Profiles\Inc; ..\..\..\..\..\Middlewares\ST\cryptolib\Inc; ..\..\..\..\..\Middlewares\ST\cryptolib\Inc\Common; ..\..\..\..\..\Middlewares\ST\cryptolib\Inc\AES
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_Beacon.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_Beacon.bin"
  ILINK.IlinkOutputFile: BLE_Beacon.out
  ILINK.IlinkIcfFile: BlueNRG_LPS.icf
  ILINK.IlinkExtraOptions: --use_optimized_variants no
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Use_OTA_ServiceManager (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STEVAL_IDB012V1; CONFIG_DEVICE_BLUENRG_LPS; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; USER_BUTTON=BSP_PUSH1; CONFIG_HW_LS_XTAL; BLE_STACK_CUSTOM_CONF; CONFIG_OTA_USE_SERVICE_MANAGER; CONFIG_SW_OTA_DATA_LENGTH_EXT; LEGACY_ADV; CONFIG_NUM_MAX_LINKS=1
  OBJCOPY.OOCOutputFile: BLE_Beacon_Use_OTA_ServiceManager.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_Beacon_Use_OTA_ServiceManager.bin"
  ILINK.IlinkOutputFile: BLE_Beacon_Use_OTA_ServiceManager.out
  ILINK.IlinkConfigDefines: CONFIG_OTA_USE_SERVICE_MANAGER=1
configuration ExtendedAdv (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STEVAL_IDB012V1; CONFIG_DEVICE_BLUENRG_LPS; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; USER_BUTTON=BSP_PUSH1; CONFIG_HW_LS_XTAL; BLE_STACK_CUSTOM_CONF; LEGACY_ADV; EXTENDED_ADV; CONFIG_NUM_MAX_LINKS=3
  OBJCOPY.OOCOutputFile: BLE_Beacon_ExtendedAdv.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_Beacon_ExtendedAdv.bin"
  ILINK.IlinkOutputFile: BLE_Beacon_ExtendedAdv.out
configuration PeriodicAdv (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STEVAL_IDB012V1; CONFIG_DEVICE_BLUENRG_LPS; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; USER_BUTTON=BSP_PUSH1; CONFIG_HW_LS_XTAL; BLE_STACK_CUSTOM_CONF; PERIODIC_ADV; CONFIG_NUM_MAX_LINKS=3
  OBJCOPY.OOCOutputFile: BLE_Beacon_PeriodicAdv.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_Beacon_PeriodicAdv.bin"
  ILINK.IlinkOutputFile: BLE_Beacon_PeriodicAdv.out
configuration AoA_Tag (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STEVAL_IDB012V1; CONFIG_DEVICE_BLUENRG_LPS; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; USER_BUTTON=BSP_PUSH1; CONFIG_HW_LS_XTAL; BLE_STACK_CUSTOM_CONF; PERIODIC_ADV; CTE_TAG; CONFIG_NUM_MAX_LINKS=3
  OBJCOPY.OOCOutputFile: BLE_Beacon_AoA_Tag.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_Beacon_AoA_Tag.bin"
  ILINK.IlinkOutputFile: BLE_Beacon_AoA_Tag.out
  group Drivers/BSP
    ../../../../../Drivers/BSP/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_com.c bluenrg_lp_evb_i2c.c bluenrg_lp_evb_io.c bluenrg_lp_evb_led.c bluenrg_lp_evb_spi.c
    ../../../../../Drivers/BSP/Components/lps22hh_STdC/driver/: lps22hh_reg.c
    ../../../../../Drivers/BSP/Components/lsm6dsox_STdC/driver/: lsm6dsox_reg.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: startup_BlueNRG_LP.c system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../../../Drivers/Peripherals_Drivers/Src/: rf_driver_hal_power_manager.c rf_driver_hal_vtimer.c rf_driver_ll_adc.c rf_driver_ll_crc.c rf_driver_ll_dma.c rf_driver_ll_exti.c rf_driver_ll_flash.c rf_driver_ll_gpio.c rf_driver_ll_i2c.c rf_driver_ll_lpuart.c rf_driver_ll_pka_v7c.c rf_driver_ll_pwr.c rf_driver_ll_radio_2g4.c rf_driver_ll_rcc.c rf_driver_ll_rng.c rf_driver_ll_rtc.c rf_driver_ll_spi.c rf_driver_ll_tim.c rf_driver_ll_timer.c rf_driver_ll_usart.c rf_driver_ll_utils.c
  group Example/User
    ../../Src/: BLE_Beacon_main.c rf_device_it.c
  group Middlewares/AES
    ../../../../../Middlewares/ST/AESMGR/Src/: aes_manager_bluenrg_lp.c
  group Middlewares/BLE_Stack
    ../../../../../Middlewares/ST/Bluetooth_LE/Library/: libbluenrg_lp_stack.a
    ../../../../../Middlewares/ST/Bluetooth_LE/Src/: stack_user_cfg.c
  group Middlewares/BLECNTR
    ../../../../../Middlewares/ST/BLECNTR/Src/: ble_controller.c ble_controller_bluenrg_lp.c
  group Middlewares/Cryptolib
    ../../../../../Middlewares/ST/cryptolib/: aes_hw.c libcrypto.a
  group Middlewares/Hal
    ../../../../../Middlewares/ST/hal/Src/: blue_unit_conversion.s context_switch.s fifo.c hal_miscutil.c miscutil.c osal.c osal_memcpy.s
  group Middlewares/NVM
    ../../../../../Middlewares/ST/NVMDB/Src/: nvm_db.c nvm_db_conf.c nvm_db_upper_layer.c
  group Middlewares/OTA
    ../../../../../Middlewares/ST/BLE_Application/OTA/Src/: OTA_btl.c
  group Middlewares/PKA
    ../../../../../Middlewares/ST/PKAMGR/Src/: pka_manager.c pka_manager_bluenrg_lps.c
  group Middlewares/Profiles
    ../../../../../Middlewares/ST/BLE_Application/Profiles/Src/: gap_profile.c gatt_profile.c
  group Middlewares/RNG
    ../../../../../Middlewares/ST/RNGMGR/Src/: rng_manager.c rng_manager_bluenrg_lp.c
