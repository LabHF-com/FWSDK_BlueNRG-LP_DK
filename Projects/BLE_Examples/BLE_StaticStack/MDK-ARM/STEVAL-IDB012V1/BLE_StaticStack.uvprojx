# Keil uVision project BLE_StaticStack.uvprojx, settings and files
target Release (6180000::V6.18::ARMCLANG)
  device: BlueNRG-332 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.1.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BLE_StaticStack +hex
  AfterMake: ..\..\..\..\..\Utility\create_sym_lib.exe --symbols ..\..\sym_export.txt --rename BLE_STACK_Init=BLE_STACK_Init_nocallbacks !L ..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Library\static\liblps_stack.a
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER CONFIG_DEVICE_BLUENRG_LPS SUPPRESS_CONFIG_HW_WARNINGS STEVAL_IDB012V1 RESET_MANAGER_SIZE=0x28000 BLE_STACK_CUSTOM_CONF
  c misc: -fshort-enums
  c include: ..\..\Inc;..\..\..\..\..\Drivers\Peripherals_Drivers\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include;..\..\..\..\..\Middlewares\ST\hal\Inc;..\..\..\..\..\Middlewares\ST\PKAMGR\Inc;..\..\..\..\..\Middlewares\ST\RNGMGR\Inc;..\..\..\..\..\Middlewares\ST\AESMGR\Inc;..\..\..\..\..\Middlewares\ST\BLECNTR\Inc;..\..\..\..\..\Drivers\CMSIS\Include;../../../../../Drivers/BSP/STEVAL-IDB012V1/Inc;..\..\..\..\..\Drivers\BSP\Common\Inc;..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver;..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver;..\..\..\..\..\Middlewares\ST\BLE_Application\layers_inc;..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Inc;..\..\..\..\..\Middlewares\ST\BLE_Application\OTA\inc;..\..\..\..\..\Middlewares\ST\NVMDB\Inc;..\..\..\..\..\Middlewares\ST\BLE_Application\Profiles\Inc;..\..\..\..\..\Middlewares\ST\cryptolib\Inc;..\..\..\..\..\Middlewares\ST\cryptolib\Inc\Common;..\..\..\..\..\Middlewares\ST\cryptolib\Inc\AES;..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Library\static
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LPS.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_SIZE=0x28000 "
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c startup_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../../../Drivers/Peripherals_Drivers/Src/: rf_driver_hal_vtimer.c rf_driver_ll_flash.c rf_driver_ll_pka_v7c.c rf_driver_ll_timer.c rf_driver_ll_gpio.c
  group Example/User
    ../../src/: bluenrg_lp_cmd_if.c bluenrg_lp_ev_if.c rf_device_it.c Reset_Manager.c
    ../../../BLE_OTA_ResetManager/Src/: OTA_ResetManager_main.c
  group Middlewares/AES
    ../../../../../Middlewares/ST/AESMGR/Src/: aes_manager_bluenrg_lp.c
  group Middlewares/BLE_Stack
    ../../../../../Middlewares/ST/Bluetooth_LE/Library/: libbluenrg_lp_stack.a
    ../../../../../Middlewares/ST/Bluetooth_LE/Src/: stack_user_cfg.c
  group Middlewares/BLECNTR
    ../../../../../Middlewares/ST/BLECNTR/Src/: ble_controller.c ble_controller_bluenrg_lp.c
  group Middlewares/Cryptolib
    ../../../../../Middlewares/ST/cryptolib/: aes_hw.c libcrypto.a
  group Middlewares/Hal
    ../../../../../Middlewares/ST/hal/Src/: blue_unit_conversion.s hal_miscutil.c miscutil.c osal.c osal_memcpy.s
  group Middlewares/NVM
    ../../../../../Middlewares/ST/NVMDB/Src/: nvm_db.c nvm_db_conf.c nvm_db_upper_layer.c
  group Middlewares/PKA
    ../../../../../Middlewares/ST/PKAMGR/Src/: pka_manager.c pka_manager_bluenrg_lps.c
  group Middlewares/Profiles
    ../../../../../Middlewares/ST/BLE_Application/Profiles/Src/: gap_profile.c gatt_profile.c
  group Middlewares/RNG
    ../../../../../Middlewares/ST/RNGMGR/Src/: rng_manager.c rng_manager_bluenrg_lp.c
target Basic (6180000::V6.18::ARMCLANG)
  device: BlueNRG-332 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.1.1
  cpu: as above
  output: BLE_StaticStack_Basic +hex
  AfterMake: ..\..\..\..\..\Utility\create_sym_lib.exe --symbols ..\..\sym_export.txt --rename BLE_STACK_Init=BLE_STACK_Init_nocallbacks !L ..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Library\static\liblps_stack_basic.a
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER CONFIG_DEVICE_BLUENRG_LPS SUPPRESS_CONFIG_HW_WARNINGS STEVAL_IDB012V1 RESET_MANAGER_SIZE=0x18000 BLE_STACK_BASIC_CONF CONFIG_NUM_MAX_LINKS=1
  c misc: -fshort-enums
  c include: as above
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LPS.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_SIZE=0x18000 "
target OTA_BTL_ResetManager (6180000::V6.18::ARMCLANG)
  device: BlueNRG-332 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.1.1
  cpu: as above
  output: BLE_StaticStack_OTA_BTL_ResetManager +hex
  AfterMake: ..\..\..\..\..\Utility\create_sym_lib.exe --symbols ..\..\sym_export.txt --rename BLE_STACK_Init=BLE_STACK_Init_nocallbacks !L ..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Library\static\liblps_stack_rstmngr.a
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: -fshort-enums
  c include: as above
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LPS.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_SIZE=0x28000 "
target OTA_BTL_ResetManager_Basic (6180000::V6.18::ARMCLANG)
  device: BlueNRG-332 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.1.1
  cpu: as above
  output: BLE_StaticStack_OTA_BTL_ResetManager_Basic +hex
  AfterMake: ..\..\..\..\..\Utility\create_sym_lib.exe --symbols ..\..\sym_export.txt --rename BLE_STACK_Init=BLE_STACK_Init_nocallbacks !L ..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Library\static\liblps_stack_rstmngr_basic.a
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: -fshort-enums
  c include: as above
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LPS.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_SIZE=0x18000 "
