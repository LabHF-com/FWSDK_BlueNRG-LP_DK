# Keil uVision project HAL_TimeBase_RTC_ALARM.uvprojx, settings and files
target HAL_TimeBase_RTC_ALARM (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.1.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HAL_TimeBase_RTC_ALARM +hex
  AfterMake: fromelf.exe --bin HAL_TimeBase_RTC_ALARM\Objects\HAL_TimeBase_RTC_ALARM.axf --output HAL_TimeBase_RTC_ALARM\Objects\HAL_TimeBase_RTC_ALARM.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER STEVAL_IDB011V1 CONFIG_DEVICE_BLUENRG_LP CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 CONFIG_HW_LS_XTAL
  c include: ..\../Inc;..\../../../../../../Drivers/Peripherals_Drivers/Inc;..\../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Include;..\../../../../../../Drivers/CMSIS/Include;..\../../../../../../Drivers/BSP/Common/Inc;..\../../../../../../Drivers/BSP/Components/lsm6dsox_STdC/driver;..\../../../../../../Drivers/BSP/Components/lps22hh_STdC/driver;../../../../../../../Drivers/BSP/STEVAL-IDB011V1/Inc;..\../../../../../../Middlewares/ST/hal/inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
  group Application/User
    ../../Src/: rf_driver_hal_timebase_rtc_alarm.c HAL_TimeBase_RTC_ALARM_main.c bluenrg_lp_it.c bluenrg_lp_hal_msp.c
  group Drivers/BSP
    ../../../../../../../Drivers/BSP/STEVAL-IDB011V1/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_led.c bluenrg_lp_evb_io.c bluenrg_lp_evb_com.c
  group Drivers/Peripherals_Drivers
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: rf_driver_hal_rtc.c rf_driver_hal_rtc_ex.c rf_driver_hal_gpio.c rf_driver_hal_rcc.c rf_driver_hal_rcc_ex.c rf_driver_hal_flash.c rf_driver_hal_flash_ex.c rf_driver_hal_dma.c rf_driver_hal_pwr.c rf_driver_hal_pwr_ex.c rf_driver_hal_cortex.c rf_driver_hal.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
