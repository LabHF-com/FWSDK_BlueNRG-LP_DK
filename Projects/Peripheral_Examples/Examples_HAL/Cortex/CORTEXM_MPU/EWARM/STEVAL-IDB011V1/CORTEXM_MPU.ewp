# IAR project CORTEXM_MPU.ewp, settings and files
configuration CORTEXM_MPU (ARM, debug)
  General.OGChipSelectEditMenu: BlueNRG-355 ST BlueNRG-355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STEVAL_IDB011V1; CONFIG_DEVICE_BLUENRG_LP; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; CONFIG_HW_LS_XTAL
  ICCARM.CCIncludePath2: ..\../Inc; ..\../../../../../../Drivers/Peripherals_Drivers/Inc; ..\../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Include; ..\../../../../../../Drivers/CMSIS/Include; ..\../../../../../../Drivers/BSP/Common/Inc; ..\../../../../../../Drivers/BSP/Components/lsm6dsox_STdC/driver; ..\../../../../../../Drivers/BSP/Components/lps22hh_STdC/driver; ..\../../../../../../Drivers/BSP/STEVAL-IDB011V1/Inc; ..\../../../../../../Middlewares/ST/hal/inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CORTEXM_MPU.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\CORTEXM_MPU.bin"
  ILINK.IlinkOutputFile: CORTEXM_MPU.out
  ILINK.IlinkIcfFile: BlueNRG_LP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Test_Access_permitted (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: CORTEXM_MPU_Test_Access_permitted.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\CORTEXM_MPU_Test_Access_permitted.bin"
  ILINK.IlinkOutputFile: CORTEXM_MPU_Test_Access_permitted.out
configuration Test_Access_NOT_permitted (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STEVAL_IDB011V1; CONFIG_DEVICE_BLUENRG_LP; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; CONFIG_HW_LS_XTAL; ACCESS_PERMISSION
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: CORTEXM_MPU_Test_Access_NOT_permitted.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\CORTEXM_MPU_Test_Access_NOT_permitted.bin"
  ILINK.IlinkOutputFile: CORTEXM_MPU_Test_Access_NOT_permitted.out
  group Application/User
    ../../Src/: bluenrg_lp_it.c bluenrg_lp_mpu.c CORTEXM_MPU_main.c bluenrg_lp_hal_msp.c
  group Drivers/BSP
    ../../../../../../../Drivers/BSP/STEVAL-IDB011V1/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_com.c bluenrg_lp_evb_io.c bluenrg_lp_evb_led.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../../../../../Drivers/Peripherals_Drivers/src/: rf_driver_hal.c rf_driver_hal_cortex.c rf_driver_hal_dma.c rf_driver_hal_flash.c rf_driver_hal_flash_ex.c rf_driver_hal_gpio.c rf_driver_hal_pwr.c rf_driver_hal_pwr_ex.c rf_driver_hal_rcc.c rf_driver_hal_rcc_ex.c
