# IAR project USART_Rx_IT_Cont_Init.ewp, settings and files
configuration USART_Rx_IT_Cont_Init (ARM, debug)
  General.OGChipSelectEditMenu: BlueNRG-355 ST BlueNRG-355
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STEVAL_IDB011V1; CONFIG_DEVICE_BLUENRG_LP; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; CONFIG_HW_LS_XTAL
  ICCARM.CCIncludePath2: ..\../Inc; ..\../../../../../../Drivers/Peripherals_Drivers/Inc; ..\../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Include; ..\../../../../../../Drivers/CMSIS/Include; ..\../../../../../../Middlewares/ST/hal/inc; ..\../../../../../../Drivers/BSP/STEVAL-IDB011V1/Inc; ..\../../../../../../Drivers/BSP/Common/Inc; ..\../../../../../../Drivers/BSP/Components/lsm6dsox_STdC/driver; ..\../../../../../../Drivers/BSP/Components/lps22hh_STdC/driver
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USART_Rx_IT_Cont_Init.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\USART_Rx_IT_Cont_Init.bin"
  ILINK.IlinkOutputFile: USART_Rx_IT_Cont_Init.out
  ILINK.IlinkIcfFile: BlueNRG_LP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../../Src/: bluenrg_lp_it.c USART_Rx_IT_Cont_Init_main.c
  group Drivers/BSP
    ../../../../../../../Drivers/BSP/STEVAL-IDB011V1/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_led.c bluenrg_lp_evb_io.c bluenrg_lp_evb_com.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: rf_driver_ll_dma.c rf_driver_ll_exti.c rf_driver_ll_gpio.c rf_driver_ll_pwr.c rf_driver_ll_rcc.c rf_driver_ll_usart.c rf_driver_ll_utils.c
