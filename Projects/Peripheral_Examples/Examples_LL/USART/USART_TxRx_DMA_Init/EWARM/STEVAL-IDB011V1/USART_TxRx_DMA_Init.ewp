# IAR project USART_TxRx_DMA_Init.ewp, settings and files
configuration USART_TxRx_DMA_Init (ARM, debug)
  General.OGChipSelectEditMenu: BlueNRG-355 ST BlueNRG-355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STEVAL_IDB011V1; CONFIG_DEVICE_BLUENRG_LP; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; CONFIG_HW_LS_XTAL; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\BLUENRG_LP\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\Peripherals_Drivers\Inc; ..\../../../../../../Middlewares/ST/hal/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USART_TxRx_DMA_Init.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\USART_TxRx_DMA_Init.bin"
  ILINK.IlinkOutputFile: USART_TxRx_DMA_Init.out
  ILINK.IlinkIcfFile: BlueNRG_LP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/RF_DRIVER_LL_Driver
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: rf_driver_ll_utils.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Example
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: rf_driver_ll_exti.c rf_driver_ll_gpio.c rf_driver_ll_usart.c
  group Example/User
    ../../Src/: bluenrg_lp_it.c USART_TxRx_DMA_Init_main.c
