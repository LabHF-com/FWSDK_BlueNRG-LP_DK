# Keil uVision project LPUART_TxRx.uvprojx, settings and files
target LPUART_TxRx (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.1.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LPUART_TxRx +hex
  AfterMake: fromelf.exe --bin LPUART_TxRx\Objects\LPUART_TxRx.axf --output LPUART_TxRx\Objects\LPUART_TxRx.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: STEVAL_IDB011V1 CONFIG_DEVICE_BLUENRG_LP CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 CONFIG_HW_LS_XTAL
  c include: ..\..\Inc;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\BLUENRG_LP\Include;..\..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\..\Drivers\Peripherals_Drivers\Inc;..\../../../../../../Middlewares/ST/hal/inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
  group Drivers/RF_DRIVER_LL_Driver
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: rf_driver_ll_utils.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Example/User
    ../../Src/: bluenrg_lp_it.c LPUART_TxRx_main.c
