<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\I2C_MasterTx_SlaveRx.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>BUILD_ALL</name>
            <member>
                <project>I2C_MasterTx_SlaveRx</project>
                <configuration>I2C_MasterTx_SlaveRx</configuration>
            </member>
            <member>
                <project>I2C_MasterTx_SlaveRx</project>
                <configuration>Master_board</configuration>
            </member>
            <member>
                <project>I2C_MasterTx_SlaveRx</project>
                <configuration>Slave_board</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
