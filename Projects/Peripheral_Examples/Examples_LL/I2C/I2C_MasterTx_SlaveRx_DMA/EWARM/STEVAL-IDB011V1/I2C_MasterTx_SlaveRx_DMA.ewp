# IAR project I2C_MasterTx_SlaveRx_DMA.ewp, settings and files
configuration I2C_MasterTx_SlaveRx_DMA (ARM, debug)
  General.OGChipSelectEditMenu: BlueNRG-355 ST BlueNRG-355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STEVAL_IDB011V1; USE_FULL_LL_DRIVER; CONFIG_DEVICE_BLUENRG_LP; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; CONFIG_HW_LS_XTAL
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\BLUENRG_LP\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\Peripherals_Drivers\Inc; ..\../../../../../../Middlewares/ST/hal/inc; ..\../../../../../../Drivers/BSP/STEVAL-IDB011V1/Inc; ..\../../../../../../Drivers/BSP/Common/Inc; ..\../../../../../../Drivers/BSP/Components/lsm6dsox_STdC/driver; ..\../../../../../../Drivers/BSP/Components/lps22hh_STdC/driver
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C_MasterTx_SlaveRx_DMA.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\I2C_MasterTx_SlaveRx_DMA.bin"
  ILINK.IlinkOutputFile: I2C_MasterTx_SlaveRx_DMA.out
  ILINK.IlinkIcfFile: BlueNRG_LP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Master_board (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: I2C_MasterTx_SlaveRx_DMA_Master_board.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\I2C_MasterTx_SlaveRx_DMA_Master_board.bin"
  ILINK.IlinkOutputFile: I2C_MasterTx_SlaveRx_DMA_Master_board.out
configuration Slave_board (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STEVAL_IDB011V1; USE_FULL_LL_DRIVER; CONFIG_DEVICE_BLUENRG_LP; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; CONFIG_HW_LS_XTAL; SLAVE_BOARD
  OBJCOPY.OOCOutputFile: I2C_MasterTx_SlaveRx_DMA_Slave_board.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\I2C_MasterTx_SlaveRx_DMA_Slave_board.bin"
  ILINK.IlinkOutputFile: I2C_MasterTx_SlaveRx_DMA_Slave_board.out
  group Drivers/RF_DRIVER_LL_Driver
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: rf_driver_ll_exti.c rf_driver_ll_gpio.c rf_driver_ll_i2c.c rf_driver_ll_utils.c
  group Drivers/BSP
    ../../../../../../../Drivers/BSP/STEVAL-IDB011V1/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_io.c bluenrg_lp_evb_com.c bluenrg_lp_evb_led.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Example/User
    ../../Src/: bluenrg_lp_it.c I2C_MasterTx_SlaveRx_DMA_main.c
