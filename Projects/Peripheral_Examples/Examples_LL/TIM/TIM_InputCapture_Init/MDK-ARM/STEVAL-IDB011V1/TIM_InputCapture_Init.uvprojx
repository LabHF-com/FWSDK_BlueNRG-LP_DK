# Keil uVision project TIM_InputCapture_Init.uvprojx, settings and files
target TIM_InputCapture_Init (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.1.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: TIM_InputCapture_Init +hex
  AfterMake: fromelf.exe --bin TIM_InputCapture_Init\Objects\TIM_InputCapture_Init.axf --output TIM_InputCapture_Init\Objects\TIM_InputCapture_Init.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_FULL_LL_DRIVER STEVAL_IDB011V1 CONFIG_DEVICE_BLUENRG_LP CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 CONFIG_HW_LS_XTAL
  c include: ..\../Inc;..\../../../../../../Drivers/Peripherals_Drivers/Inc;..\../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Include;..\../../../../../../Drivers/CMSIS/Include;..\../../../../../../Middlewares/ST/hal/inc;../../../../../../../Drivers/BSP/STEVAL-IDB011V1/Inc;..\../../../../../../Drivers/BSP/Common/Inc;..\../../../../../../Drivers/BSP/Components/lsm6dsox_STdC/driver;..\../../../../../../Drivers/BSP/Components/lps22hh_STdC/driver
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
  group Application/User
    ../../Src/: TIM_InputCapture_Init_main.c bluenrg_lp_it.c
  group Drivers/BSP
    ../../../../../../../Drivers/BSP/STEVAL-IDB011V1/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_led.c bluenrg_lp_evb_io.c bluenrg_lp_evb_com.c
  group Drivers/Peripherals_Drivers
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: rf_driver_ll_utils.c rf_driver_ll_exti.c rf_driver_ll_gpio.c rf_driver_ll_exti.c rf_driver_ll_pwr.c rf_driver_ll_tim.c rf_driver_ll_dma.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
