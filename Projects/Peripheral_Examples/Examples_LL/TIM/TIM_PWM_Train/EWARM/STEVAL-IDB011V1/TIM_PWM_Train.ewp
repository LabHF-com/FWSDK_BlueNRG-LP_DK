# IAR project TIM_PWM_Train.ewp, settings and files
configuration TIM_PWM_Train (ARM, debug)
  General.OGChipSelectEditMenu: BlueNRG-355 ST BlueNRG-355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STEVAL_IDB011V1; CONFIG_DEVICE_BLUENRG_LP; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; CONFIG_HW_LS_XTAL
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\BLUENRG_LP\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\Peripherals_Drivers\Inc; ..\../../../../../../Middlewares/ST/hal/inc; ..\../../../../../../Drivers/BSP/STEVAL-IDB011V1/Inc; ..\../../../../../../Drivers/BSP/Common/Inc; ..\../../../../../../Drivers/BSP/Components/lsm6dsox_STdC/driver; ..\../../../../../../Drivers/BSP/Components/lps22hh_STdC/driver
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TIM_PWM_Train.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\TIM_PWM_Train.bin"
  ILINK.IlinkOutputFile: TIM_PWM_Train.out
  ILINK.IlinkIcfFile: BlueNRG_LP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/BSP
    ../../../../../../../Drivers/BSP/STEVAL-IDB011V1/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_led.c bluenrg_lp_evb_io.c bluenrg_lp_evb_com.c
  group Drivers/RF_DRIVER_LL_Driver
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: rf_driver_ll_utils.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Example/User
    ../../Src/: bluenrg_lp_it.c TIM_PWM_Train_main.c
