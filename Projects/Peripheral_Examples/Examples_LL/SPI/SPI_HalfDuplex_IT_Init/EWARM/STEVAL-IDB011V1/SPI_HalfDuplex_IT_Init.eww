<workspace>
  <project>
    <path>$WS_DIR$\SPI_HalfDuplex_IT_Init.ewp</path>
  </project>
  <batchBuild />
</workspace>