<workspace>
  <project>
    <path>$WS_DIR$\SPI_HalfDuplex_DMA_Init.ewp</path>
  </project>
  <batchBuild />
</workspace>