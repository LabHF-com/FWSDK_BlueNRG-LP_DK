# Keil uVision project RCC_HSEStartupTest.uvprojx, settings and files
target RCC_HSEStartupTest (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.1.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: RCC_HSEStartupTest +hex
  AfterMake: fromelf.exe --bin RCC_HSEStartupTest\Objects\RCC_HSEStartupTest.axf --output RCC_HSEStartupTest\Objects\RCC_HSEStartupTest.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_FULL_LL_DRIVER STEVAL_IDB011V1 CONFIG_DEVICE_BLUENRG_LP CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 CONFIG_HW_LS_XTAL
  c include: ..\../Inc;..\../../../../../../Drivers/Peripherals_Drivers/Inc;..\../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Include;..\../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/BSP/STEVAL-IDB011V1/Inc;..\../../../../../../Drivers/BSP/Common/Inc;..\../../../../../../Drivers/BSP/Components/lsm6dsox_STdC/driver;..\../../../../../../Drivers/BSP/Components/lps22hh_STdC/driver;..\../../../../../../Middlewares/ST/hal/inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
  group Application/User
    ../../Src/: bluenrg_lp_it.c RCC_HSEStartupTest_main.c
  group Drivers/BSP
    ../../../../../../../Drivers/BSP/STEVAL-IDB011V1/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_com.c bluenrg_lp_evb_io.c bluenrg_lp_evb_led.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../../../../../Drivers/Peripherals_Drivers/src/: rf_driver_hal_power_manager.c rf_driver_hal_vtimer.c rf_driver_ll_gpio.c rf_driver_ll_timer.c
  group Middlewares/Hal
    ../../../../../../../Middlewares/ST/hal/Src/: blue_unit_conversion.s context_switch.s hal_miscutil.c osal_memcpy.s
