<workspace>
  <project>
    <path>$WS_DIR$\SPI_HD_Polling_IT_Master.ewp</path>
  </project>
  <batchBuild />
</workspace>