# IAR project RADIO_Sleep.ewp, settings and files
configuration Tx (ARM, debug)
  General.OGChipSelectEditMenu: BlueNRG-355 ST BlueNRG-355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STEVAL_IDB011V1; CONFIG_DEVICE_BLUENRG_LP; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; CONFIG_HW_LS_XTAL
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\..\Middlewares\ST\hal\inc; ..\..\..\..\..\..\..\Drivers\BSP\Common\Inc; ..\..\..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver; ..\..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver; ..\..\..\..\..\..\..\Drivers\Peripherals_Drivers\Inc; ..\..\..\..\..\..\..\Drivers/BSP/STEVAL-IDB011V1/Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RADIO_Sleep_Tx.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\RADIO_Sleep_Tx.bin"
  ILINK.IlinkOutputFile: RADIO_Sleep_Tx.out
  ILINK.IlinkIcfFile: BlueNRG_LP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Rx (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: RADIO_Sleep_Rx.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\RADIO_Sleep_Rx.bin"
  ILINK.IlinkOutputFile: RADIO_Sleep_Rx.out
  group Application/User
    ../../Src/: bluenrg_lp_it.c RADIO_Sleep_RX_main.c RADIO_Sleep_TX_main.c
  group Drivers/BSP
    ../../../../../../../Drivers/BSP/STEVAL-IDB011V1/Src/: bluenrg_lp_evb_com.c bluenrg_lp_evb_led.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Drivers/Peripheral_Drivers
    ../../../../../../../Drivers/Peripherals_Drivers/src/: rf_driver_hal_power_manager.c rf_driver_hal_radio_2g4.c rf_driver_hal_vtimer.c rf_driver_ll_radio_2g4.c rf_driver_ll_timer.c
  group Hal
    ../../../../../../../Middlewares/ST/hal/Src/: blue_unit_conversion.s context_switch.s osal.c osal_memcpy.s
