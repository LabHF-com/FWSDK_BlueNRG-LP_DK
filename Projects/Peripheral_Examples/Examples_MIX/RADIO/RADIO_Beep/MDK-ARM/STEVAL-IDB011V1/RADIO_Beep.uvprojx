# Keil uVision project RADIO_Beep.uvprojx, settings and files
target Beep_Encryption (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.1.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: RADIO_Beep_Beep_Encryption +hex
  AfterMake: fromelf.exe --bin Beep_Encryption\Objects\RADIO_Beep_Beep_Encryption.axf --output Beep_Encryption\Objects\RADIO_Beep_Beep_Encryption.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: PACKET_ENCRYPTION STEVAL_IDB011V1 CONFIG_DEVICE_BLUENRG_LP CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 CONFIG_HW_LS_XTAL
  c include: ..\..\Inc;..\..\..\..\..\..\..\Middlewares\ST\hal\inc;..\..\..\..\..\..\..\Drivers\BSP\Common\Inc;..\..\..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver;..\..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver;..\..\..\..\..\..\..\Drivers\Peripherals_Drivers\Inc;../../../../../../../Drivers/BSP/STEVAL-IDB011V1/Inc;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include;..\..\..\..\..\..\..\Drivers\CMSIS\Include
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
  group Application/User
    ../../Src/: bluenrg_lp_it.c RADIO_Beep_main.c
  group Drivers/BSP
    ../../../../../../../Drivers/BSP/STEVAL-IDB011V1/Src/: bluenrg_lp_evb_led.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: rf_driver_hal_vtimer.c rf_driver_ll_radio_2g4.c rf_driver_ll_timer.c
  group Hal
    ../../../../../../../Middlewares/ST/hal/Src/: blue_unit_conversion.s osal.c
target Beep_NO_Encryption (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.1.0.0
  cpu: as above
  output: RADIO_Beep_Beep_NO_Encryption +hex
  AfterMake: fromelf.exe --bin Beep_NO_Encryption\Objects\RADIO_Beep_Beep_NO_Encryption.axf --output Beep_NO_Encryption\Objects\RADIO_Beep_Beep_NO_Encryption.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: STEVAL_IDB011V1 CONFIG_DEVICE_BLUENRG_LP CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 CONFIG_HW_LS_XTAL
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
