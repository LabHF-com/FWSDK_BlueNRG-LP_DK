# IAR project RADIO_RemoteControl.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: BlueNRG-355 ST BlueNRG-355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USER_BUTTON=BSP_PUSH1; STEVAL_IDB011V1; CONFIG_DEVICE_BLUENRG_LP; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; CONFIG_HW_LS_XTAL
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\..\Middlewares\ST\hal\inc; ..\..\..\..\..\..\..\Drivers\BSP\Common\Inc; ..\..\..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver; ..\..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver; ..\..\..\..\..\..\..\Drivers\Peripherals_Drivers\Inc; ..\..\..\..\..\..\..\Drivers/BSP/STEVAL-IDB011V1/Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RADIO_RemoteControl.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\RADIO_RemoteControl.bin"
  ILINK.IlinkOutputFile: RADIO_RemoteControl.out
  ILINK.IlinkIcfFile: BlueNRG_LP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../../Src/: bluenrg_lp_it.c RADIO_RemoteControl_main.c
  group Drivers/BSP
    ../../../../../../../Drivers/BSP/STEVAL-IDB011V1/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_led.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Drivers/Peripheral_Drivers
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: rf_driver_hal_radio_2g4.c rf_driver_hal_vtimer.c rf_driver_ll_radio_2g4.c rf_driver_ll_timer.c
  group Hal
    ../../../../../../../Middlewares/ST/hal/Src/: blue_unit_conversion.s osal.c
