<workspace>
  <project>
    <path>$WS_DIR$\FLASH_BasicDemo.ewp</path>
  </project>
  <batchBuild />
</workspace>