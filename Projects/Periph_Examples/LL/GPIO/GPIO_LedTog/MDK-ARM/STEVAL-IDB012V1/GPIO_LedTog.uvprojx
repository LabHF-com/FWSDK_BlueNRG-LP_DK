# Keil uVision project GPIO_LedTog.uvprojx, settings and files
target Release (6160000::V6.16::ARMCLANG)
  device: BlueNRG-332 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.1.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: GPIO_LedTog +hex
  AfterMake: fromelf.exe --bin Release\Objects\GPIO_LedTog.axf --output Release\Objects\GPIO_LedTog.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER STEVAL_IDB012V1 CONFIG_DEVICE_BLUENRG_LPS CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 CONFIG_HW_LS_XTAL
  c misc: -fshort-enums
  c include: ..\..\Inc;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include;..\..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\..\Drivers\Peripherals_Drivers\Inc;..\..\..\..\..\..\..\Middlewares/ST/hal/Inc;..\..\..\..\..\..\..\Drivers/BSP/Inc;..\..\..\..\..\..\..\Drivers/BSP/Components/lsm6dsox_STdC/driver;..\..\..\..\..\..\..\Drivers/BSP/Components/lps22hh_STdC/driver
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LPS.sct
  group Drivers/RF_DRIVER_LL_Driver
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: rf_driver_ll_gpio.c rf_driver_ll_utils.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c startup_BlueNRG_LP.c
  group Example/User
    ../../Src/: rf_device_it.c GPIO_LedTog_main.c
