# Keil uVision project SPI_IT_Master_Init.uvprojx, settings and files
target Release (6160000::V6.16::ARMCLANG)
  device: BlueNRG-332 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.1.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SPI_IT_Master_Init +hex
  AfterMake: fromelf.exe --bin Release\Objects\SPI_IT_Master_Init.axf --output Release\Objects\SPI_IT_Master_Init.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER STEVAL_IDB012V1 CONFIG_DEVICE_BLUENRG_LPS CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 CONFIG_HW_LS_XTAL
  c misc: -fshort-enums
  c include: ..\..\Inc;..\..\..\..\..\..\..\Drivers/Peripherals_Drivers/Inc;..\..\..\..\..\..\..\Drivers/CMSIS/Device/ST/BlueNRG_LP/Include;..\..\..\..\..\..\..\Drivers/CMSIS/Include;..\..\..\..\..\..\..\Middlewares/ST/hal/Inc;..\..\..\..\..\..\..\Drivers/BSP/Inc;..\..\..\..\..\..\..\Drivers/BSP/Components/lsm6dsox_STdC/driver;..\..\..\..\..\..\..\Drivers/BSP/Components/lps22hh_STdC/driver
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LPS.sct
  group Application/User
    ../../Src/: rf_device_it.c SPI_IT_Master_Init_main.c
  group Drivers/BSP
    ../../../../../../../Drivers/BSP/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_com.c bluenrg_lp_evb_io.c bluenrg_lp_evb_led.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c startup_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: rf_driver_ll_dma.c rf_driver_ll_exti.c rf_driver_ll_gpio.c rf_driver_ll_pwr.c rf_driver_ll_spi.c rf_driver_ll_utils.c
target 8bit (6160000::V6.16::ARMCLANG)
  device: BlueNRG-332 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.1.1
  cpu: as above
  output: SPI_IT_Master_Init_8bit +hex
  AfterMake: fromelf.exe --bin 8bit\Objects\SPI_IT_Master_Init_8bit.axf --output 8bit\Objects\SPI_IT_Master_Init_8bit.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER STEVAL_IDB012V1 CONFIG_DEVICE_BLUENRG_LPS CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 CONFIG_HW_LS_XTAL CONFIG_DATASIZE_8BIT USE_SPI1_PINS
  c misc: -fshort-enums
  c include: as above
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LPS.sct
