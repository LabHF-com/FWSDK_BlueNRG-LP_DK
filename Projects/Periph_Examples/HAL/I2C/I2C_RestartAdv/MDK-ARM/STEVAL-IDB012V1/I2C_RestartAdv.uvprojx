# Keil uVision project I2C_RestartAdv.uvprojx, settings and files
target Master_board (6160000::V6.16::ARMCLANG)
  device: BlueNRG-332 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.1.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: I2C_RestartAdv_Master_board +hex
  AfterMake: fromelf.exe --bin Master_board\Objects\I2C_RestartAdv_Master_board.axf --output Master_board\Objects\I2C_RestartAdv_Master_board.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER STEVAL_IDB012V1 CONFIG_DEVICE_BLUENRG_LPS CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 CONFIG_HW_LS_XTAL MASTER_BOARD
  c misc: -fshort-enums
  c include: ..\..\Inc;..\..\..\..\..\..\..\Drivers/Peripherals_Drivers/Inc;..\..\..\..\..\..\..\Drivers/CMSIS/Device/ST/BlueNRG_LP/Include;..\..\..\..\..\..\..\Drivers/CMSIS/Include;..\..\..\..\..\..\..\Drivers/BSP/Inc;..\..\..\..\..\..\..\Drivers/BSP/Components/lsm6dsox_STdC/driver;..\..\..\..\..\..\..\Drivers/BSP/Components/lps22hh_STdC/driver;..\..\..\..\..\..\..\Middlewares/ST/hal/Inc
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LPS.sct
  group Application/User
    ../../Src/: rf_device_hal_msp.c rf_device_it.c I2C_RestartAdv_main.c
  group Drivers/BSP
    ../../../../../../../Drivers/BSP/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_io.c bluenrg_lp_evb_com.c bluenrg_lp_evb_led.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c startup_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: rf_driver_hal.c rf_driver_hal_cortex.c rf_driver_hal_dma.c rf_driver_hal_flash.c rf_driver_hal_flash_ex.c rf_driver_hal_gpio.c rf_driver_hal_i2c.c rf_driver_hal_i2c_ex.c rf_driver_hal_pwr.c rf_driver_hal_pwr_ex.c rf_driver_hal_rcc.c rf_driver_hal_rcc_ex.c rf_driver_hal_uart.c rf_driver_hal_uart_ex.c
target Slave_board (6160000::V6.16::ARMCLANG)
  device: BlueNRG-332 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.1.1
  cpu: as above
  output: I2C_RestartAdv_Slave_board +hex
  AfterMake: fromelf.exe --bin Slave_board\Objects\I2C_RestartAdv_Slave_board.axf --output Slave_board\Objects\I2C_RestartAdv_Slave_board.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER STEVAL_IDB012V1 CONFIG_DEVICE_BLUENRG_LPS CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 CONFIG_HW_LS_XTAL
  c misc: -fshort-enums
  c include: as above
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LPS.sct
