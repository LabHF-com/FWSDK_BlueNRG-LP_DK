# Keil uVision project RADIO_OTA_RM.uvprojx, settings and files
target Client (6160000::V6.16::ARMCLANG)
  device: BlueNRG-332 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.1.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: RADIO_OTA_RM_Client +hex
  AfterMake: fromelf.exe --bin Client\Objects\RADIO_OTA_RM_Client.axf --output Client\Objects\RADIO_OTA_RM_Client.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER _DEBUG STEVAL_IDB012V1 CONFIG_OTA_SERVICE_MANAGER CONFIG_DEVICE_BLUENRG_LPS CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 CONFIG_HW_LS_XTAL
  c misc: -fshort-enums
  c include: ..\..\Inc;..\..\..\..\..\..\..\Middlewares\ST\hal\Inc;..\..\..\..\..\..\..\Drivers\BSP\Inc;..\..\..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver;..\..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver;..\..\..\..\..\..\..\Drivers\Peripherals_Drivers\Inc;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include;..\..\..\..\..\..\..\Drivers\CMSIS\Include
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LPS.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_SIZE=0x2800 "
  group Application/User
    ../../Src/: binary_image_txrx_example.c rf_device_it.c RADIO_OTAClient_main.c RADIO_OTAServer_main.c RADIO_OTAServerFixedImage_main.c ymodem.c
  group Drivers/BSP
    ../../../../../../../Drivers/BSP/Src/: bluenrg_lp_evb_com.c bluenrg_lp_evb_led.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c startup_BlueNRG_LP.c
  group Drivers/Peripheral_Drivers
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: rf_driver_hal_radio_2g4.c rf_driver_hal_vtimer.c rf_driver_ll_flash.c rf_driver_ll_radio_2g4.c rf_driver_ll_rcc.c rf_driver_ll_timer.c
  group Hal
    ../../../../../../../Middlewares/ST/hal/Src/: blue_unit_conversion.s clock.c gp_timer.c osal.c
target Server_Ymodem (6160000::V6.16::ARMCLANG)
  device: BlueNRG-332 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.1.1
  cpu: as above
  output: RADIO_OTA_RM_Server_Ymodem +hex
  AfterMake: fromelf.exe --bin Server_Ymodem\Objects\RADIO_OTA_RM_Server_Ymodem.axf --output Server_Ymodem\Objects\RADIO_OTA_RM_Server_Ymodem.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER SERVER_YMODEM STEVAL_IDB012V1 _DEBUG CONFIG_DEVICE_BLUENRG_LPS CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 CONFIG_HW_LS_XTAL
  c misc: -fshort-enums
  c include: as above
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LPS.sct
target Server_FixedImage (6160000::V6.16::ARMCLANG)
  device: BlueNRG-332 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.1.1
  cpu: as above
  output: RADIO_OTA_RM_Server_FixedImage +hex
  AfterMake: fromelf.exe --bin Server_FixedImage\Objects\RADIO_OTA_RM_Server_FixedImage.axf --output Server_FixedImage\Objects\RADIO_OTA_RM_Server_FixedImage.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: -fshort-enums
  c include: as above
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LPS.sct
