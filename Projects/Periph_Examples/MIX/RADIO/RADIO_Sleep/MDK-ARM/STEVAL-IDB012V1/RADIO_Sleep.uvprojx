# Keil uVision project RADIO_Sleep.uvprojx, settings and files
target Tx (6160000::V6.16::ARMCLANG)
  device: BlueNRG-332 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.1.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: RADIO_Sleep_Tx +hex
  AfterMake: fromelf.exe --bin Tx\Objects\RADIO_Sleep_Tx.axf --output Tx\Objects\RADIO_Sleep_Tx.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER STEVAL_IDB012V1 CONFIG_DEVICE_BLUENRG_LPS CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 CONFIG_HW_LS_XTAL
  c misc: -fshort-enums
  c include: ..\..\Inc;..\..\..\..\..\..\..\Middlewares\ST\hal\Inc;..\..\..\..\..\..\..\Drivers\BSP\Inc;..\..\..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver;..\..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver;..\..\..\..\..\..\..\Drivers\Peripherals_Drivers\Inc;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include;..\..\..\..\..\..\..\Drivers\CMSIS\Include
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LPS.sct
  group Application/User
    ../../Src/: rf_device_it.c RADIO_Sleep_RX_main.c RADIO_Sleep_TX_main.c
  group Drivers/BSP
    ../../../../../../../Drivers/BSP/Src/: bluenrg_lp_evb_com.c bluenrg_lp_evb_led.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c startup_BlueNRG_LP.c
  group Drivers/Peripheral_Drivers
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: rf_driver_hal_power_manager.c rf_driver_hal_radio_2g4.c rf_driver_hal_vtimer.c rf_driver_ll_radio_2g4.c rf_driver_ll_timer.c
  group Hal
    ../../../../../../../Middlewares/ST/hal/Src/: blue_unit_conversion.s context_switch.s osal.c osal_memcpy.s osal.c
target Rx (6160000::V6.16::ARMCLANG)
  device: BlueNRG-332 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.1.1
  cpu: as above
  output: RADIO_Sleep_Rx +hex
  AfterMake: fromelf.exe --bin Rx\Objects\RADIO_Sleep_Rx.axf --output Rx\Objects\RADIO_Sleep_Rx.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: -fshort-enums
  c include: as above
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LPS.sct
