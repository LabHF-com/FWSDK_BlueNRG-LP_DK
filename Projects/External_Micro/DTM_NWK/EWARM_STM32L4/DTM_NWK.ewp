# IAR project DTM_NWK.ewp, settings and files
configuration DTM_NWK_UART (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32L476xx; HCLK_32MHZ=1; DEBUG=1; ENABLE_USART=1; UART_INTERFACE; DTM_UART
  ICCARM.CCIncludePath2: ..\inc\; ..\..\..\..\Drivers\External_micro\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\Drivers\External_micro\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\Drivers\External_micro\BSP\STM32Lxx_Nucleo\Inc; ..\..\..\..\Drivers\External_micro\BSP\STM32Lxx_BlueNRGLP\Inc; ..\..\..\..\Middlewares\ST\External_micro\STM32L1xx_HAL_BlueNRG-LP_Drivers\inc; ..\..\..\..\Middlewares\ST\External_micro\HAL\Inc; ..\..\..\..\Middlewares\ST\External_micro\SimpleBlueNRG-LP_HCI\includes; ..\..\..\..\Middlewares\ST\External_micro\SimpleBlueNRG-LP_HCI; ..\..\..\..\Middlewares\ST\Bluetooth_LE\Inc; ..\..\..\..\Middlewares\ST\BLE_Application\layers_inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: DTM_NWK_UART.hex
  ILINK.IlinkOutputFile: DTM_NWK_UART.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DTM_NWK_SPI (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L476xx; HCLK_32MHZ=1; DEBUG=1; ENABLE_USART=1; SPI_INTERFACE; DTM_SPI; __DMA_16
  OBJCOPY.OOCOutputFile: DTM_NWK_SPI.hex
  ILINK.IlinkOutputFile: DTM_NWK_SPI.out
  group Application/EWARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../src/: DTM_NWK_main.c hci_bridge.c stm32xx_it.c
  group Drivers/BSP/STM32L4xx_BlueNRGLP
    ../../../../Drivers/External_micro/BSP/STM32Lxx_BlueNRGLP/Src/: SDK_EVAL_GPIO.c SDK_EVAL_Spi.c SDK_EVAL_Uart.c
  group Drivers/BSP/STM32L4xx_Nucleo
    ../../../../Drivers/External_micro/BSP/STM32Lxx_Nucleo/Src/: SDK_EVAL_Com.c SDK_EVAL_Led.c
  group Drivers/CMSIS
    ../../../../Drivers/External_micro/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../Drivers/External_micro/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_utils.c
  group Middlewares/HCI
    ../../../../Middlewares/ST/External_micro/SimpleBlueNRG-LP_HCI/hci/: hci_parser.c
  group Middlewares/STM32_BlueNRGLP/HAL
    ../../../../Middlewares/ST/External_micro/HAL/Src/: clock.c gp_timer.c list.c osal.c
